SRCREV = "f6d0859f9435796f03ae93b70b5f92f4406bc56d"

PREMIRRORS_prepend = " \
    git://git.freescale.com/imx/.* https://github.com/NXP/BASENAME \n \
"
