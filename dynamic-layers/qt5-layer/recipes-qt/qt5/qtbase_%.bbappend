SRC_URI_remove = " file://Environment-variable-enabling-the-workaround-FBO-rea.patch"

QT_CONFIG_FLAGS_APPEND = "-eglfs"
